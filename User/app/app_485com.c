#include <ucos_ii.h>
#include "app_485com.h"
#include "app_usbcom.h"
#include "app_485modbusslave.h"
#include "app_kernelregs.h"
#include "bsp_485.h"
#include "app_encryption.h"

//串口的后台线程
struct _C485COM_Backend
{
	//缓冲
	u8 buff[1024];

	//空闲位置，指向数据后面的空白
	int buffend;

	//状态机 0空闲 1接收 2处理
	unsigned char state;

	//设备是否打开
	char comopen;

	int allcnt;

	//待检查时间
	u32 tickstime;
	//时间记录
	u32 oldtickstime;

}C485COM_Backend;

typedef enum {FALSE = 0, TRUE = !FALSE} bool;

static void StartTimer(unsigned int time)
{
	C485COM_Backend.tickstime = (OS_TICKS_PER_SEC/1000) * time;
	C485COM_Backend.oldtickstime = OSTimeGet();
}

static bool CheckTimer()
{
	if((OSTimeGet() - C485COM_Backend.oldtickstime) > C485COM_Backend.tickstime)
	{
		return TRUE;
	}
	else
	{
		return FALSE;
	}
}

extern void printint(int num);


// CRC 高位字节值表
static unsigned char auchCRCHi[] = {
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
		0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
		0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
		0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
		0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
		0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
		0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
		0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
		0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
		0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
		0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
		0x80, 0x41, 0x00, 0xC1, 0x81, 0x40
} ;

// CRC低位字节值表
static char auchCRCLo[] = {
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,
		0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD,
		0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
		0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A,
		0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,
		0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
		0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,
		0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,
		0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
		0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29,
		0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,
		0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
		0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,
		0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67,
		0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
		0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,
		0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,
		0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
		0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,
		0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92,
		0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
		0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B,
		0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,
		0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
		0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,
		0x43, 0x83, 0x41, 0x81, 0x80, 0x40
} ;


//CRC校验的函数
u16 CRC16(unsigned char *puchMsg, unsigned short usDataLen)
{
	unsigned char uchCRCHi = 0xFF ; /* 高CRC字节初始化 */
	unsigned char uchCRCLo = 0xFF ; /* 低CRC 字节初始化 */
	unsigned uIndex ; /* CRC循环中的索引 */
	while (usDataLen--) /* 传输消息缓冲区 */
	{
		uIndex = uchCRCHi ^ *puchMsg++ ; /* 计算CRC */
		uchCRCHi = uchCRCLo ^ auchCRCHi[uIndex] ;
		uchCRCLo = auchCRCLo[uIndex] ;
	}
	return (uchCRCHi << 8 | uchCRCLo) ;
}

/*
com初始化
*/
void C485COM_Init(void)
{
	//状态初始化
	C485COM_Backend.state = 0;
	C485COM_Backend.buffend = 0;
	C485COM_Backend.allcnt = 0;
}

//打开设备
void C485COM_Open(void)
{
    C485COM_Backend.comopen = 1;
}

//关闭设备
void C485COM_Close(void)
{
	if (C485COM_Backend.comopen == 1)
	{
		C485COM_Backend.comopen = 0;
	}
}

//任务执行
void C485COM_Run(void *p_arg)
{
    C485COM_Init();
	C485COM_Open();

    while(1)
	{
	//只要串口打开，则后台运行
	if(C485COM_Backend.comopen )
	{
#ifdef TEST485
	    u8 buff[30];
		u16 l = 0;
		if(BSP_485InBuffLen()>0)
		{
			l = BSP_485Read(buff,BSP_485InBuffLen());
			BSP_485Write(buff,l);
		}
#else

		int cnt = 0;
		
		//查询校验结果
		if(App_Encryption_Invalid() == 1)
		{
			OSTimeDlyHMSM(0, 0, 0, 1);
			continue;
		}

		//空闲态
		if(C485COM_Backend.state == 0)
		{
		  //收到字符
		  if((cnt = BSP_485InBuffLen()) > 0)
		  {
			//3.5T定时器
		    StartTimer(5);
			C485COM_Backend.state = 1;

			BSP_485Read(C485COM_Backend.buff,cnt);

			C485COM_Backend.buffend = cnt;
		  }
		}

		//接收态
		if(C485COM_Backend.state == 1)
		{
		  //帧分隔时间到
		  if(CheckTimer() == TRUE)
		  {
		     C485COM_Backend.state = 2;
		  }
		  //收到字符
		  else if((cnt = BSP_485InBuffLen()) > 0)
		  {
			//3.5T定时器
		    StartTimer(5);

			//数据过长，只取一共1024个数据(含原来的数据)
			if(cnt+C485COM_Backend.buffend > 1024)
			{
				//实际读的数据长度，否则溢出
				BSP_485Read(C485COM_Backend.buff + C485COM_Backend.buffend,(1024-C485COM_Backend.buffend));

				C485COM_Backend.buffend = 1024;
			}
			else
			{
				//没有溢出，全部读
				BSP_485Read(C485COM_Backend.buff +  C485COM_Backend.buffend,cnt);

				C485COM_Backend.buffend = cnt + C485COM_Backend.buffend;
			}
		  }
		}

		//处理态
		if(C485COM_Backend.state == 2)
		{
		   //目标为自己
		   if(C485COM_Backend.buff[0] == MODBUSID)
		   {

			  //根据功能码发送给不同的任务处理
			  switch(C485COM_Backend.buff[1])
			  {
			  	//读控制器数据
			  case 0x03:
			  	//写控制器数据,单个
			  case 0x06:
			  	//写控制器数据
			  case 0x10:

					C485_ModbusSlave_ProcessFrame(C485COM_Backend.buff,C485COM_Backend.buffend);
					break;

			  default:
				  ;
			  }
		   }
		   //清理buff和串口buff
		   C485COM_Backend.buffend = 0;
		   C485COM_Backend.state = 0;
		   BSP_485ClearReadBuff();
		}
#endif		

	}

	OSTimeDlyHMSM(0, 0, 0, 1);
	}
}


//写字符
int C485COM_Write(u8* chardata,int len)
{
	if(C485COM_Backend.comopen)
	{
		BSP_485Write(chardata, len);
	}
	return len;
}


